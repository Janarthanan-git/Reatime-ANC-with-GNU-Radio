options:
  parameters:
    generate_options: qt_gui
    id: ANC
    output_language: python
    title: ANC
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\Jana\Downloads\Refernce noise.wav
    repeat: 'True'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self, mu=0.01, length=32):
              gr.sync_block.__init__(self,
                  name="lms_filter",
                  in_sig=[np.float32, np.float32],
                  out_sig=[np.float32])
              self.mu = mu
              self.length = length
              self.w = np.zeros(length)
              self.x_buf = np.zeros(length)

          def work(self, input_items, output_items):
              ref = input_items[0]
              primary = input_items[1]
              error = output_items[0]

              for i in range(len(ref)):
                  self.x_buf = np.roll(self.x_buf, -1)
                  self.x_buf[-1] = ref[i]
                  y = np.dot(self.w, self.x_buf)
                  e = primary[i] - y
                  self.w += self.mu * e * self.x_buf
                  error[i] = e
              return len(error)
    length: '32'
    mu: '0.1'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Freq Sink"'
    nconnections: '3'
    type: float
    wintype: window.WIN_FLATTOP
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Time Sink"'
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [audio_source_0, '0', epy_block_0, '1']
- [audio_source_0, '0', qtgui_freq_sink_x_0, '1']
- [audio_source_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_wavfile_source_0, '0', epy_block_0, '0']
- [blocks_wavfile_source_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', qtgui_time_sink_x_0, '0']
- [epy_block_0, '0', audio_sink_0, '0']
- [epy_block_0, '0', qtgui_freq_sink_x_0, '2']
- [epy_block_0, '0', qtgui_time_sink_x_0, '2']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
